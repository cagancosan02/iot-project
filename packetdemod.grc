options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: channel_freq
  states: {}
- name: channel_freq
  id: variable_qtgui_range
  parameters:
    start: 433.92e6
    step: '1000'
    stop: 433.92e6
    value: '433920000'
  states: {}
- name: channel_width
  id: variable_qtgui_range
  parameters:
    start: '500'
    step: '100'
    stop: '50000'
    value: '20000'
  states: {}
- name: fftsize
  id: variable
  parameters:
    value: '512'
  states: {}
- name: manchester_decoding
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    beta: '6.76'
    decim: '1'
    gain: '1'
    high_cutoff_freq: channel_freq - center_freq + channel_width/2
    low_cutoff_freq: channel_freq - center_freq - channel_width/2
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: '1000'
    win: window.WIN_KAISER
  states: {state: disabled}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '10000'
    low_cutoff_freq: '-10000'
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.06'
    init: '0'
    low: '0.04'
  states: {}
- name: ook_demod_block
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each this file is saved, GRC will instantiate the first class it finds to get
      ports and parameters of your block. The arguments to __init__  will be the
      parameters. All of them are required to have default values!
      """
      import time
      import numpy as np
      from gnuradio import gr

      class blk (gr.sync_block):
          """
          Block to decode the data on an already squared signal, comprised of 0's and 1's.
          """

          def __init__ (self, 
                      symbol_rate = 1e3,
                      sample_rate = 2.4e6,
                      manchester_decoding = False,
                      #sink_file = None
                      ):  # only default arguments here
              """
              Constructor.

              Args:
                  symbol_rate -> Rate of symbols

                  sample_rate -> Number of samples per second

              manchester_decoding -> Enable/disable manchester decoding

                  sink_file -> File to dump the packets. If it's 'None', prints them on STDOUT
              """
              gr.sync_block.__init__(
                  self,
                  name = 'OOK demod',
                  in_sig = [np.float32],
                  out_sig = []
              )

              self.manchester_decoding = True

              #self.sink_file = None
              #if(sink_file != None):
              #      self.sink_file = open(sink_file, "a")

              # amount of samples per symbol
              self.threshold = sample_rate / symbol_rate
              # amount of samples that can be wrong when counting the 1's and 0's
              self.error_threshold = self.threshold

              self.packet = ''
              self.count_1 = 0 # Counts consecutive 1's
              self.count_0 = 0 # Counts consecutive 0's
              self.sample_1_complete = False
              self.sample_0_complete = False


          def packet_found(self):
            self.packet += '0' # Last 0 of packet is never detected due to the bounded 0 count (in process_sample_0), so add manually

            if(self.manchester_decoding):
              self.packet = self.manchester_decoder(self.packet)

            self.output_packet(self.packet)
            self.packet = ''

         
          def output_packet(self, output):
            #if(self.sink_file):
            #  self.sink_file.write(output + '\n')
            #else:
            if len(output) > 5:
              print("\nbits = " + output + "\n")


          def count_samples(self, sample1, sample2):
            if(sample1 == 1):
              self.count_1 += 1
              if(sample2 == 0):
                self.sample_1_complete = True 
            elif(sample1 == 0):
              self.count_0 += 1
              if(sample2 == 1):
                self.sample_0_complete = True 


          def process_sample_0(self):
            if(self.count_0 > self.threshold - self.error_threshold and self.count_0 < self.threshold + self.error_threshold):
              self.packet += '0'
            elif(self.count_0 > (self.threshold - self.error_threshold) * 2 and self.count_0 < (self.threshold + self.error_threshold) * 2):
              self.packet += '00'
            self.count_0 = 0
            self.sample_0_complete = False


          def process_sample_1(self):
            if(self.count_1 > self.threshold - self.error_threshold and self.count_1 < self.threshold + self.error_threshold):
              self.packet += '1'
            elif(self.count_1 > (self.threshold - self.error_threshold) * 2 and self.count_1 < (self.threshold + self.error_threshold) * 2):
              self.packet += '11'
            self.count_1 = 0
            self.sample_1_complete = False


          def manchester_decoder(self, packet):
            decode = ''

            for i in range(0, len(packet) - 1, 2):
              bits = packet[i] + packet[i + 1]
              if(bits == '10'):
                decode += '0'
              elif(bits == '01'):
                decode += '1'
              else:
                i -= 1

            return decode



          def work (self, input_items, *args, **kwargs):
            samples = input_items[0]
            signal_detected = np.where(samples == 1)[0]
            

            if(len(signal_detected) > 0):
              for i in range(0, len(samples) - 1):
                self.count_samples(samples[i], samples[i + 1])
                if(self.sample_1_complete):
                  self.process_sample_1()
                elif(self.sample_0_complete):
                  self.process_sample_0()
            elif(len(samples) > 0 and len(self.packet) > 0):
              self.packet_found()

            return len(samples)
    manchester_decoding: 'True'
    sample_rate: 1e6
    symbol_rate: 4e3
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: ''
    label2: ''
    name: '"Magnitude"'
    nconnections: '2'
    size: fftsize
    srate: samp_rate
    tr_level: '0.018'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '0.4'
    ymin: '0'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: fftsize
    name: '"Raw samples"'
    showports: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: fftsize
    name: '"Post-filter"'
    showports: 'True'
    type: complex
  states: {state: disabled}
- name: rtlsdr_source_0_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    corr0: '20'
    freq0: 433.92e6
    gain0: '30'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: '2400000.0'
    sync: sync
    type: fc32
  states: {state: disabled}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: center_freq
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: zeromq_push_sink_0_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:5558
    timeout: '100'
    type: float
  states: {state: disabled}

connections:
- [band_pass_filter_0, '0', blocks_complex_to_mag_0, '0']
- [band_pass_filter_0, '0', qtgui_waterfall_sink_x_0_1, '0']
- [band_pass_filter_0_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_threshold_ff_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0_1_0, '0']
- [blocks_complex_to_mag_0, '0', zeromq_push_sink_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_threshold_ff_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_0_1_0, '0']
- [blocks_threshold_ff_0, '0', ook_demod_block, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_0_1_0, '1']
- [rtlsdr_source_0_0, '0', band_pass_filter_0, '0']
- [rtlsdr_source_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [soapy_rtlsdr_source_0, '0', band_pass_filter_0, '0']
- [soapy_rtlsdr_source_0, '0', band_pass_filter_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
